Commit message: fixed rotated scan data

File: pan_tilt_lidar.urdf (robot description, URDF)
Before this commit: robot pan_tilt_lidar, 4 links, 3 joints
Joints:
- joint tilt: axis 0 1 0 -> 0 -1 0
